nand_dois
*----------------------------------------------------------------------
*----------------------------------------------------------------------
*			Universidade Federal de Pelotas
*			Autor: Luiz Guilherme M S Ito
*			Curso: Engenharia Eletrônica
*					Microeletrônica
*----------------------------------------------------------------------
*----------------------------------------------------------------------
*
*----------------------------------------------------------
*----------------------------------------------------------
.include amis_c5n.txt
*----------------------------------------------------------
*----------------------------------------------------------
M1 vcc in1 out vcc CMOSP l=0.5u w=2.4u pd=4.2u ad=0.6p ps=4.2u as=0.6p
M2 vcc in2 out vcc CMOSP l=0.5u w=2.4u pd=4.2u ad=0.6p ps=4.2u as=0.6p
M3 out in1  2   0  CMOSN l=0.5u w=1.2u pd=4.2u ad=0.6p ps=4.2u as=0.6p
M4  2  in2  0   0  CMOSN l=0.5u w=1.2u pd=4.2u ad=0.6p ps=4.2u as=0.6p
*----------------------------------------------------------
*----------------------------------------------------------
V1 vcc 0 dc 5
V2 gnd 0 dc 0
V3 in1 0 pulse (0 5 10n 0 0 20n 40n)
V4 in2 0 pulse (0 5 20n 0 0 40n 80n)
*----------------------------------------------------------
*----------------------------------------------------------
.control
 * passo = 0.1ps, tempo = 100ns
 tran 2p 5n
 * atribui valor DC para as curvas não ficarem sobrepostas
 plot in1 in2+6 out+12
*----------------------------------------------------------
*----------------------------------------------------------
.endc
.end
